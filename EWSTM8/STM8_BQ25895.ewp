# IAR project STM8_BQ25895.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L051F3 STM8L051F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\inc; ..\STM8L15x_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group inc
    ../inc/: bq2589x_reg.h main.h soft_i2c.h stm8l15x_conf.h stm8l15x_it.h
  group src
    ../src/: bq2589x_charger.c main.c soft_i2c.c stm8l15x_it.c
  group STM8L15x_StdPeriph_Driver/inc
    ../STM8L15x_StdPeriph_Driver/inc/: stm8l15x.h
  group STM8L15x_StdPeriph_Driver/src
    ../STM8L15x_StdPeriph_Driver/src/: stm8l15x_clk.c stm8l15x_gpio.c
