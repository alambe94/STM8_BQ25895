<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\STM8_BQ25895.ewp</path>
    </project>
    <batchBuild />
</workspace>
